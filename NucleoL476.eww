<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Project\stm32l476rg.ewp</path>
    </project>
    <batchBuild />
</workspace>
